# IAR project SimpleLib_workspace.ewp, settings and files
configuration SimpleLib_workspace (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../BUPT_RobotTeam_Libraries/SimpleLib; ../BUPT_RobotTeam_Libraries/SimpleLib/can; ../BUPT_RobotTeam_Libraries/SimpleLib/cmd; ../BUPT_RobotTeam_Libraries/SimpleLib/core; ../BUPT_RobotTeam_Libraries/SimpleLib/flash; ../BUPT_RobotTeam_Libraries/SimpleLib/module; ../BUPT_RobotTeam_Libraries/SimpleLib/nrf; ../BUPT_RobotTeam_Libraries/SimpleLib/utils; ../BUPT_RobotTeam_Libraries/SimpleLib/peripherals; ../BUPT_RobotTeam_Libraries/ChassisLib; ../BUPT_RobotTeam_Libraries/MotorLib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: SimpleLib_workspace.hex
  ILINK.IlinkOutputFile: SimpleLib_workspace.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User/ChassisLib
    ../BUPT_RobotTeam_Libraries/ChassisLib/: base_chassis.c base_chassis.h chassis_common_config.h handle.c handle.h omni_chassis.c omni_chassis.h point.c point.h point_parser.c point_parser.h rudder_chassis.c rudder_chassis.h steer_wheel.c steer_wheel.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/MotorLib
    ../BUPT_RobotTeam_Libraries/MotorLib/: dji_board_can_v1.c dji_board_can_v1.h dji_boardv2_can.c dji_boardv2_can.h driver_pro_can.c driver_pro_can.h motor_driver.c motor_driver.h odrive_can.c odrive_can.h rm_cxxx_can.c rm_cxxx_can.h vesc_can.c vesc_can.h
  group Application/User/SimpleLib
    ../BUPT_RobotTeam_Libraries/SimpleLib/: simplelib.c simplelib.h simplelib_cfg.h
  group Application/User/SimpleLib/can
    ../BUPT_RobotTeam_Libraries/SimpleLib/can/: can_func.c can_func.h can_utils.c can_utils.h
  group Application/User/SimpleLib/cmd
    ../BUPT_RobotTeam_Libraries/SimpleLib/cmd/: cmd.c cmd.h cmd_func.c cmd_func.h
  group Application/User/SimpleLib/core
    ../BUPT_RobotTeam_Libraries/SimpleLib/core/: flags.c flags.h
  group Application/User/SimpleLib/flash
    ../BUPT_RobotTeam_Libraries/SimpleLib/flash/: flash.c flash.h stmflash.c stmflash.h
  group Application/User/SimpleLib/module
    ../BUPT_RobotTeam_Libraries/SimpleLib/module/: as5047p.c as5047p.h imitate_spi.c imitate_spi.h toolBoxScope.c toolBoxScope.h
  group Application/User/SimpleLib/nrf
    ../BUPT_RobotTeam_Libraries/SimpleLib/nrf/: nrf24l01.c nrf24l01.h nrf_comm.c nrf_comm.h
  group Application/User/SimpleLib/peripherals
    ../BUPT_RobotTeam_Libraries/SimpleLib/peripherals/: laser.c laser.h led_board.c led_board.h locator.c locator.h
  group Application/User/SimpleLib/utils
    ../BUPT_RobotTeam_Libraries/SimpleLib/utils/: hash.c hash.h kalman.c kalman.h utils.c utils.h vec.c vec.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
